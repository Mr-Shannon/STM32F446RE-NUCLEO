# Keil uVision project Project.uvprojx, settings and files
target STM32F446RE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F446xx
  c include: ..\Applications;..\Drivers;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../Applications/: main.c board.c
  group Driver
    ../Drivers/: usart.c tools.c sccb.c i2s.c
  group CMSIS
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_iwdg.c
